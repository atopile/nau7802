File: elec/layout/default/nau7802.kicad_pcb (KiCad board)
At the start: 2 copper layers, 7 parts

Commit message: build with latest
Parts:
- R1, R2: value 51Ω ±1% 62.5mW -> 47Ω ±1% 62.5mW
